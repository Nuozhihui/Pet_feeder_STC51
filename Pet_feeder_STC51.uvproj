# Keil uVision project Pet_feeder_STC51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Pet_feeder_STC51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIB\DHT11;.\LIB\LCD
  group Source Group 1
    ./: MAIN.c
  group LIB
    ./LIB/DHT11/: DHT11.c
    ./LIB/LCD/: lcd.c
